## linux-2.6.32/drivers/test/Kconfig
```kconfig
#
# DREIVE_TEST device configuration
#
config DREIVE_TEST
	tristate "DREIVE_TEST"
	default m
	help
	  This is a test 
```
